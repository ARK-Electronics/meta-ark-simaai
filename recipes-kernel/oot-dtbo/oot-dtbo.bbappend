require recipes-core/images/ark-compatible-machine.inc
