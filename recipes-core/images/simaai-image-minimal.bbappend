require recipes-core/images/ark-compatible-machine.inc

require recipes-core/images/ark-image.inc
